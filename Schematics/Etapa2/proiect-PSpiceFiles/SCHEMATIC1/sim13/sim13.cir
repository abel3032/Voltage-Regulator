** Profile: "SCHEMATIC1-sim13"  [ d:\proiectul_meu\proiect-pspicefiles\schematic1\sim13.sim ]

** Creating circuit file "sim13.cir"
** WARNING: THIS AUTOMATICALLY GENERATED FILE MAY BE OVERWRITTEN BY SUBSEQUENT SIMULATIONS

*Libraries:
* Profile Libraries :
* Local Libraries :
.LIB "C:/Users/alber/OneDrive/Desktop/librarii_proiect/Lib_ModelePSpice_Anexa_1/Modele_A1_lib/SMLS14BET.lib"
.LIB "C:/Users/alber/OneDrive/Desktop/librarii_proiect/Lib_ModelePSpice_Anexa_1/Modele_A1_lib/BC856B.lib"
.LIB "C:/Users/alber/OneDrive/Desktop/librarii_proiect/Lib_ModelePSpice_Anexa_1/Modele_A1_lib/BZX84C5V6.lib"
.LIB "C:/Users/alber/OneDrive/Desktop/librarii_proiect/Lib_ModelePSpice_Anexa_1/Modele_A1_lib/BC846B.lib"
.LIB "C:/Users/alber/OneDrive/Desktop/librarii_proiect/Lib_ModelePSpice_Anexa_1/Modele_A1_lib/MJD31CG.lib"
.LIB "C:/Users/alber/OneDrive/Desktop/librarii_proiect/Lib_ModelePSpice_Anexa_1/Modele_A1_lib/BC817-25.lib"
.LIB "C:/Users/alber/OneDrive/Desktop/librarii_proiect/Lib_ModelePSpice_Anexa_1/Modele_A1_lib/BZX84C2V7.lib"
.LIB "C:/Users/alber/OneDrive/Desktop/librarii_proiect/Lib_ModelePSpice_Anexa_1/Modele_A1_lib/BZX84C5V1.lib"
.LIB "C:/Users/alber/OneDrive/Desktop/librarii_proiect/Lib_ModelePSpice_Anexa_1/Modele_A1_lib/BZX84C6V8.lib"
* From [PSPICE NETLIST] section of C:\Users\alber\AppData\Roaming\SPB_Data\cdssetup\OrCAD_PSpice/16.6.0/PSpice.ini file:
.lib "nomd.lib"

*Analysis directives:
.DC LIN V_V1 0 24 0.01
.OPTIONS ADVCONV
.PROBE64 V(alias(*)) I(alias(*)) W(alias(*)) D(alias(*)) NOISE(alias(*))
.INC "..\SCHEMATIC1.net"

.END
